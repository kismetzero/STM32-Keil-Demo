# Keil uVision project STM32F103C8T6.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8T6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c misc: -Wno-invalid-utf8
  c include: .\Libraries;.\System;.\Hardware
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Libraries
    ./Libraries/: OLED.c OLED.h OLED_Data.c OLED_Data.h
  group System
    ./System/: Delay.c Delay.h PWM.c PWM.h Timer.c Timer.h Serial.c Serial.h USART1.c USART1.h SWI2C.c SWI2C.h
  group Hardware
    ./Hardware/: LED.c LED.h Key.c Key.h Buzzer.c Buzzer.h DTH11.c DTH11.h HX1838.c HX1838.h DS3231.c DS3231.h W25Q128JV.c W25Q128JV.h AT24C32.c AT24C32.h SHT40.c SHT40.h AHT20.c AHT20.h BMP280.c BMP280.h EC11.c EC11.h
  group User
    ./User/: main.c pin-use.txt
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
